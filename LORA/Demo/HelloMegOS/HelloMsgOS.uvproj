# Keil uVision project HelloMsgOS.uvproj, settings and files
target MsgOS (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: MsgOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SCF
  group driver
    ./SCF/: driver.h init.c driver.c Flash.c
  group systerm
    ./SCF/: system.h main.c task.c memory.c shell.c
  group apply
    ./SCF/: apply.h
  group readme
    ./SCF/: readme.txt
