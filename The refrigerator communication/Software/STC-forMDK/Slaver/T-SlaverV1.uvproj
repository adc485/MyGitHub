# Keil uVision project T-SlaverV1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: T-SlaverV1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 T-SlaverV1-main.c T-SlaverV1_Uart.c T-SlaverV1_Protocol.c T-SlaverV1_Delay.c T-SlaverV1_Check.c T-SlaverV1_Mac.c
